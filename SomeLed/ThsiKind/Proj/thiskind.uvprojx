# Keil uVision project thiskind.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: thiskind +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../APP/: app.c stm32f10x_it.c
  group uC-OS-II/Port
    ../uCOSProt/: os_cpu_c.c os_dbg.c cpu_a.asm os_cpu_a.asm
  group uC-OS-II/Source
    ../uCOSSource/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
software components: CMSIS:CORE 4.1.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
