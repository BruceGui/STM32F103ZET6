# Keil uVision project newp.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: newp
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:GPIO 3.5.0
