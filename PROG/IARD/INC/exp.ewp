# IAR project exp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: F:\OperatingSys\EmbeddedLove\STM32F103ZET6\www.own.com.cn\Micrium\Software\uCOS-III\Source; F:\OperatingSys\EmbeddedLove\STM32F103ZET6\www.own.com.cn\Micrium\Software\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; F:\OperatingSys\EmbeddedLove\STM32F103ZET6\www.own.com.cn\Micrium\Software\uC-CPU; F:\OperatingSys\EmbeddedLove\STM32F103ZET6\www.own.com.cn\Micrium\Software\uC-CPU\ARM-Cortex-M3\IAR; F:\OperatingSys\EmbeddedLove\STM32F103ZET6\www.own.com.cn\Micrium\Software\uC-LIB; F:\OperatingSys\EmbeddedLove\STM32F103ZET6\www.own.com.cn\Micrium\Software\uC-LIB\Ports\ARM-Cortex-M3\IAR; F:\OperatingSys\EmbeddedLove\STM32F103ZET6\www.own.com.cn\Micrium\Software\myboards\inc; F:\OperatingSys\EmbeddedLove\STM32F103ZET6\www.own.com.cn\Micrium\Software\myboards\STM32\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: exp.srec
  ILINK.IlinkOutputFile: exp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group bsp
    ../../../Micrium/Software/myboards/BSP/: bsp.c
  group cosiii
    ../../../Micrium/Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../../Micrium/Software/uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group lib
    ../../../Micrium/Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../../Micrium/Software/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group stm32
    ../../../Micrium/Software/myboards/STM32/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uCCPU
    ../../../Micrium/Software/uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
    ../../../Micrium/Software/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group user
    ../../../Micrium/Software/myboards/user/: app.c
