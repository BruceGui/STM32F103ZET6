# Keil uVision project own.uvprojx, settings and files
target ARR (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: own +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: Gpio.c ownprintf.c Retarget.c STM32_Init.c usart.c STM32F10x.s ownprintf.h STM32_Init.h usart.h
