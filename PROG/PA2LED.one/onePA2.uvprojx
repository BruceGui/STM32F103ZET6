# Keil uVision project onePA2.uvprojx, settings and files
target STM32 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: onePA2 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ./: STM32F10x.s
  group initialisation
    ./: STM32_Init.c
  group source
    ./: Gpio.c Retarget.c usart.c
software components: CMSIS:CORE 4.1.0
